# IAR project hc110Lora.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: REGION_CN470=1
  ICCARM.CCIncludePath2: mcu\common; driver\inc; app; app\inc; app\inc\components; app\inc\components\sx1276; app\inc\lora; app\inc\lora\conf; app\inc\lora\core; app\inc\lora\crypto; app\inc\lora\mac; app\inc\lora\mac\region; app\inc\lora\phy; app\inc\lora\utilities
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: hc110Lora.bin
  ILINK.IlinkOutputFile: hc110Lora.out
  ILINK.IlinkIcfFile: mcu\EWARM\config\hc32l110.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptStrategy: 0
  group app/inc
    app/inc/: ddl_device.h hc32L110UserGpioExt.h hc32L110UserLpt.h hc32L110UserRtc.h hc32L110UserSpi.h hc32L110UserUart.h initDevice.h queue.h timeService.h
  group app/inc/components
    app/inc/components/: rfEntry.h
  group app/inc/components/sx1276
    app/inc/components/sx1276/: sx1276.h sx1276Regs-Fsk.h sx1276Regs-LoRa.h
  group app/inc/lora/conf
    app/inc/Lora/Conf/: Comissioning.h
  group app/inc/lora/core
    app/inc/Lora/Core/: lora.h lora_mac_version.h
  group app/inc/lora/crypto
    app/inc/Lora/Crypto/: aes.h cmac.h
  group app/inc/lora/mac
    app/inc/Lora/Mac/: LoRaMac.h LoRaMacCrypto.h LoRaMacTest.h timer.h
  group app/inc/lora/mac/region
    app/inc/Lora/Mac/region/: Region.h RegionAS923.h RegionAU915.h RegionCN470.h RegionCN779.h RegionCommon.h RegionEU433.h RegionEU868.h RegionIN865.h RegionKR920.h RegionUS915-Hybrid.h RegionUS915.h
  group app/inc/lora/phy
    app/inc/Lora/Phy/: radio.h
  group app/inc/lora/utilities
    app/inc/Lora/utilities/: delay.h low_power.h utilities.h
  group app/src
    app/src/: appMain.c hc32L110UserGpioExt.c hc32L110UserLpt.c hc32L110UserRtc.c hc32L110UserSpi.c hc32L110UserUart.c initDevice.c queue.c timeService.c
  group app/src/components
    app/src/Components/: rfEntry.c
  group app/src/components/sx1276
    app/src/Components/sx1276/: sx1276.c
  group app/src/lora/core
    app/src/Lora/Core/: lora.c
  group app/src/lora/crypto
    app/src/Lora/Crypto/: aes.c cmac.c
  group app/src/lora/mac
    app/src/Lora/Mac/: LoRaMac.c LoRaMacCrypto.c
  group app/src/lora/mac/region
    app/src/Lora/Mac/region/: Region.c RegionAS923.c RegionAU915.c RegionCN470.c RegionCN779.c RegionCommon.c RegionEU433.c RegionEU868.c RegionIN865.c RegionKR920.c RegionUS915-Hybrid.c RegionUS915.c
  group app/src/lora/utilities
    app/src/Lora/Utilities/: low_power.c utilities.c
  group driver/inc
    driver/inc/: adc.h adt.h bt.h clk.h crc.h ddl.h flash.h gpio.h i2c.h lpm.h lpt.h lpuart.h lvd.h pca.h reset.h rtc.h spi.h trim.h uart.h vc.h wdt.h
  group driver/src
    driver/src/: adc.c adt.c bt.c clk.c crc.c ddl.c flash.c gpio.c i2c.c lpm.c lpt.c lpuart.c lvd.c pca.c reset.c rtc.c spi.c trim.c uart.c vc.c wdt.c
  group mcu
    mcu/common/: base_types.h
  group mcu/common
    mcu/common/: HC32L110.h startup_hc32l110.s system_hc32l110.c system_hc32l110.h
    driver/src/: interrupts_hc32l110.c
    driver/inc/: interrupts_hc32l110.h
